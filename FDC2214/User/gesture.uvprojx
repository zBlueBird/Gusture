# Keil uVision project gesture.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gesture +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Uart;..\Public;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\APP\delay;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\APP\iic;..\APP\led;..\APP\FDC2214;..\APP\key;..\APP\shoushi;..\APP\time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c stm32f10x_it.c
  group Startup
    ../Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ../APP/iic/: iic.c
    ../APP/FDC2214/: FDC2214.c
    ../APP/shoushi/: shoushi.c
    ../APP/time/: time.c
    ../APP/key/: key.c
  group Public
    ../Public/: system.c SysTick.c
  group Uart
    ../Uart/: usart1.c usart2.c
